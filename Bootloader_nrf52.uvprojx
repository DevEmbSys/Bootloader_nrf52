# Keil uVision project Bootloader_nrf52.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Bootloader_nrf52
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c include: .\config;.\components\ble\common;.\components\boards;.\components\libraries\atomic;.\components\libraries\atomic_fifo;.\components\libraries\balloc;.\components\libraries\bootloader;.\components\libraries\bootloader\ble_dfu;.\components\libraries\bootloader\dfu;.\components\libraries\crc32;.\components\libraries\crypto;.\components\libraries\crypto\backend\cc310;.\components\libraries\crypto\backend\cc310_bl;.\components\libraries\crypto\backend\cifra;.\components\libraries\crypto\backend\mbedtls;.\components\libraries\crypto\backend\micro_ecc;.\components\libraries\crypto\backend\nrf_hw;.\components\libraries\crypto\backend\nrf_sw;.\components\libraries\crypto\backend\oberon;.\components\libraries\crypto\backend\optiga;.\components\libraries\delay;.\components\libraries\experimental_section_vars;.\components\libraries\fstorage;.\components\libraries\log;.\components\libraries\log\src;.\components\libraries\mem_manager;.\components\libraries\memobj;.\components\libraries\queue;.\components\libraries\ringbuf;.\components\libraries\scheduler;.\components\libraries\sha256;.\components\libraries\stack_info;.\components\libraries\strerror;.\components\libraries\svc;.\components\libraries\util;.\components\softdevice\common;.\components\softdevice\s132\headers;.\components\softdevice\s132\headers\nrf52;..\..;.\external\fprintf;.\external\micro-ecc\micro-ecc;.\external\nano-pb;.\external\nrf_oberon;.\external\nrf_oberon\include;.\integration\nrfx;.\modules\nrfx;.\modules\nrfx\hal;.\modules\nrfx\mdk;.\config;.\User
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group Application
    ./User/: main.c
    ./Key/: public_key.c
    ./config/: sdk_config.h
  group Board Definition
    ./components/boards/: boards.c
  group nRF_BLE
    ./components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    ./components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ./components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ./components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF sw
    ./components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ./components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ./components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ./components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    ./modules/nrfx/hal/: nrf_nvmc.c
    ./modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ./components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ./components/libraries/scheduler/: app_scheduler.c
    ./components/libraries/crc32/: crc32.c
    ./components/libraries/mem_manager/: mem_manager.c
    ./components/libraries/atomic_fifo/: nrf_atfifo.c
    ./components/libraries/atomic/: nrf_atomic.c
    ./components/libraries/balloc/: nrf_balloc.c
    ./external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ./components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ./components/libraries/memobj/: nrf_memobj.c
    ./components/libraries/queue/: nrf_queue.c
    ./components/libraries/ringbuf/: nrf_ringbuf.c
    ./components/libraries/experimental_section_vars/: nrf_section_iter.c
    ./components/libraries/strerror/: nrf_strerror.c
    ./components/libraries/sha256/: sha256.c
  group nRF_Log
    ./components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ./external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.1.lib
  group nRF_SVC
    ./components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ./components/libraries/svc/: nrf_svc_handler.c
  group nRF_SoftDevice
    ./components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ./external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ./external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.29.0
